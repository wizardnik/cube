# Keil uVision project Cube_v1_Nik.uvprojx, settings and files
target Cube_v1_Nik (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F042C6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Cube_v1_Wizard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\CMSIS\Include;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source;.\STM32F0xx_StdPeriph_Driver;.\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0xx_StdPeriph_Driver\src;.\User\inc;.\User\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Startup
    ./: startup_stm32f042x6.s
  group User
    ./User/src/: mcu_ini.c main.c pwm.c alphabet.c button.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Stdperiph
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./STM32F0xx_StdPeriph_Driver/: stm32f0xx_conf.h
